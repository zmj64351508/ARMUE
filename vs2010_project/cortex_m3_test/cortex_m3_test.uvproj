# Keil uVision project cortex_m3_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: cortex_m3_test +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o ./test.bin ./cortex_m3_test.axf
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe -c -o ./test.txt ./cortex_m3_test.axf
  c flags: Optim=4
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x10000000 size 0x100000
  group Source Group 1
    ./: start.s test.c
